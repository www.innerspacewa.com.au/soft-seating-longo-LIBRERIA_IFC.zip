Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: longo_modules_with_103_cm_height_divider.ifc
Time: 2016-12-29T13:17:23
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Longo - Modules with 103 cm height divider
ePset_BIMobject_Lena - Type: LN212; Mat Seat: Orange; Mat Divider: Orange; MatStructure: White; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Longo - Modules with 103 cm height divider; SKU (BO_prodsku): LN21; ManufacturName (BO_Manufac): Actiu; ProductFamily (BO_prodfam): Soft; ProductGroup (BO_prodgroup): Longo; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 2010; Height (BO_height): 1330; Depth (BO_depth): 670; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/actiu/product/LN21; ProductDataUrl (BO_prodaturl): bimobject.com/actiu/product/LN21; InstallationInstructions (BO_montins): https://www.actiu.com/en/furniture/soft-seating/longo; ProductCertification (BO_prodcert): https://www.actiu.com/en/furniture/soft-seating/longo; TechnicalDescription (BO_techcert): https://www.actiu.com/en/furniture/soft-seating/longo; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=jwW7ziCWk3c; MaterialMain (BO_mainmat): Aluminium; MaterialSecondary (BO_secmat): Fabric; BimObjectCategory (BO_bocat): Other; IfcClassification (BO_ifcclas): Furniture; Uniclass14Code (BO_uniclass_1_4_code): L853; Uniclass14Description (BO_uniclass_1_4_desc): Office furniture; Uniclass20Code (BO_uniclass_2_0_code): SS-25-30-20-30; Uniclass20Description (BO_uniclass_2_0_desc): Frame And Door Leaf Systems; NBSReference (BO_nbs_ref): 25-30-20-30; NBSReferenceDescription (BO_nbs_desc): Frame And Door Leaf Systems; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
